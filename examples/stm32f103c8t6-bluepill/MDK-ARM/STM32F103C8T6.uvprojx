# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103C8T6 +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ..\Core\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c system_stm32f1xx.c
    ../Core/Inc/: main.h stm32f1xx_hal_conf.h stm32f1xx_it.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_def.h stm32f1xx_hal_cortex.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h
    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Include/: core_cm3.h cmsis_compiler.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_iccarm.h cmsis_version.h mpu_armv7.h
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include/: stm32f1xx.h stm32f103xb.h system_stm32f1xx.h
  group MDK-ARM
    ./: startup_stm32f103xb.s
software components: CMSIS:CORE 4.1.0
